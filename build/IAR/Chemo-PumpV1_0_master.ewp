# IAR project Chemo-PumpV1_0_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZC ST STM32L152ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xC; USE_HAL_DRIVER; DEBUG; USE_FULL_ASSERT; SSZ_TARGET_MACHINE
  ICCARM.CCIncludePath2: ..\..\config; ..\..\source; ..\..\source\common; ..\..\source\ui_common; ..\..\source\ui_common\resource; ..\..\source\ui_common\widget; ..\..\source\app; ..\..\source\app\screens; ..\..\source\middleware; ..\..\source\middleware\kernel; ..\..\source\driver; ..\..\lib\ssz_micro_sys\bsp; ..\..\lib\ssz_micro_sys\include; ..\..\lib\ssz_ui\include; ..\..\lib\ssz_ui\source; ..\..\lib\ssz_ui\include\view; ..\..\lib\ssz_ui\include\view\widget; ..\..\bsp\bsp_machine\Inc; ..\..\bsp\bsp_machine\Drivers\CMSIS\Include; ..\..\bsp\bsp_machine\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\bsp\bsp_machine\Drivers\STM32L1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Chemo-PumpV1_0_master.bin
  ILINK.IlinkOutputFile: Chemo-PumpV1_0_master.out
  ILINK.IlinkIcfFile: Chemo-PumpV1_0_master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L152xC; USE_HAL_DRIVER; NDEBUG; SSZ_TARGET_MACHINE
configuration Test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xC ST STM32L152xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32L152xC; USE_HAL_DRIVER; DEBUG; USE_FULL_ASSERT; TEST; SSZ_TARGET_MACHINE
  group bsp_machine/Drivers/CMSIS/Device/ST/STM32L1xx/Include
    ../../bsp/bsp_machine/Drivers/CMSIS/Device/ST/STM32L1xx/Include/: stm32l152xc.h stm32l1xx.h system_stm32l1xx.h
  group bsp_machine/Drivers/CMSIS/Include
    ../../bsp/bsp_machine/Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_hal.h stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.h stm32l1xx_hal_cortex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_spi.h stm32l1xx_hal_spi_ex.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/Legacy
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group bsp_machine/Drivers/STM32L1xx_HAL_Driver/Src
    ../../bsp/bsp_machine/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group bsp_machine/EWARM
    ../../bsp/bsp_machine/EWARM/: startup_stm32l152xc.s stm32l152xc_flash.icf stm32l152xc_sram.icf stm32l162xc_flash.icf stm32l162xc_sram.icf
  group bsp_machine/Inc
    ../../bsp/bsp_machine/Inc/: adc.h gpio.h main.h spi.h stm32l1xx_hal_conf.h stm32l1xx_it.h tim.h usart.h
  group bsp_machine/Src
    ../../bsp/bsp_machine/Src/: adc.c gpio.c main.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_stm32l1xx.c tim.c usart.c
  group config
    ../../config/: alarm_config.h clock.c com_config.h config.c config.h data_config.h event_config.h key_config.h msg_config.h read.c record_log_config.h screen_config.h simple_alloc_config.cpp simple_alloc_config.h ssz_config.cpp ssz_config.h ssz_ui_config.c ssz_ui_config.h ssz_ui_view_config.cpp ssz_ui_view_config.h timer_config.h write.c
  group source
    ../../source/: do_before_main_loop.cpp do_before_main_loop.h init.cpp init.h main_run.c main_run.h run_test_after_main.cpp version.c version.h
  group source/app
    ../../source/app/: app_alarm_event_handle.cpp app_alarm_event_handle.h app_check_last_infuse.cpp app_check_last_infuse.h app_cmd.cpp app_cmd.h app_common.cpp app_common.h app_delivery.cpp app_delivery.h app_infusion_event_handle.cpp app_infusion_event_handle.h app_infusion_monitor.cpp app_infusion_monitor.h app_key_event_handle.cpp app_key_event_handle.h app_mcu_comm.cpp app_mcu_comm.h app_mcu_monitor.cpp app_mcu_monitor.h app_motor_monitor.cpp app_motor_monitor.h app_msg_handle.cpp app_msg_handle.h app_scr_event_handle.cpp app_scr_event_handle.h app_sleep.cpp app_sleep.h app_startup_and_post.c app_startup_and_post.h app_system_monitor.cpp app_system_monitor.h
  group source/app/screens
    ../../source/app/screens/: app_alternative_popup.cpp app_alternative_popup.h app_history_log.cpp app_history_log.h app_home.cpp app_home.h app_main_menu.cpp app_main_menu.h app_operation_log.cpp app_operation_log.h app_popup.cpp app_popup.h app_scr_alarm.cpp app_scr_alarm.h app_scr_auto_clear_air.cpp app_scr_auto_clear_air.h app_scr_change_oled_brightness.cpp app_scr_change_oled_brightness.h app_scr_change_password.cpp app_scr_change_password.h app_scr_change_voice_volume.cpp app_scr_change_voice_volume.h app_scr_manual_clear_air.cpp app_scr_manual_clear_air.h app_scr_set_date.cpp app_scr_set_date.h app_scr_set_infusion_duration.cpp app_scr_set_infusion_duration.h app_scr_set_infusion_speed.cpp app_scr_set_infusion_speed.h app_scr_set_max_clean_tube_dose.cpp app_scr_set_max_clean_tube_dose.h app_scr_set_peek_mode_duration.cpp app_scr_set_peek_mode_duration.h app_scr_set_peek_mode_speed.cpp app_scr_set_peek_mode_speed.h app_scr_set_time.cpp app_scr_set_time.h app_scr_set_total_dose.cpp app_scr_set_total_dose.h app_scr_set_year.cpp app_scr_set_year.h app_scr_task_confirm.cpp app_scr_task_confirm.h app_select_popup.cpp app_select_popup.h app_set_menu.cpp app_set_menu.h scr_battery_calibration.cpp scr_battery_calibration.h scr_clean_tube.cpp scr_clean_tube.h scr_factory_mode.cpp scr_factory_mode.h scr_layout.cpp scr_layout.h scr_new_pressure_calibration.cpp scr_new_pressure_calibration.h scr_password_popup.cpp scr_password_popup.h scr_precision_calibration.cpp scr_precision_calibration.h scr_precision_factor.cpp scr_precision_factor.h scr_pressure_calibration.cpp scr_pressure_calibration.h scr_pressure_threshold.cpp scr_pressure_threshold.h scr_set_clean_tube_dose.cpp scr_set_clean_tube_dose.h scr_sleep.cpp scr_sleep.h scr_tip_popup.cpp scr_tip_popup.h scr_unlock_tip.cpp scr_unlock_tip.h
  group source/common
    ../../source/common/: common.c common.h dev_def.c dev_def.h
  group source/driver
    ../../source/driver/: drv_com.c drv_com.h drv_infusion_motor.c drv_infusion_motor.h drv_interrupt.c drv_interrupt.h drv_isd2360.c drv_isd2360.h drv_key.c drv_key.h drv_lowpower.c drv_lowpower.h drv_oled.c drv_oled.h drv_rtc.c drv_rtc.h drv_sst25_flash.c drv_sst25_flash.h drv_stf_motor.c drv_stf_motor.h
  group source/middleware
    ../../source/middleware/: alarm.c alarm.h alarm_play.c alarm_play.h com.c com.h data.c data.h display.c display.h infusion_motor.c infusion_motor.h key.c key.h led.c led.h mid_adc.c mid_adc.h mid_common.c mid_common.h mid_rtc.c mid_rtc.h param.c param.h param_internal.h pill_box_install_detect.c pill_box_install_detect.h pressure_bubble_sensor.c pressure_bubble_sensor.h record_log.c record_log.h record_log_text.c record_log_text.h simple_alloc.c simple_alloc.h sys_power.c sys_power.h three_valve_motor.c three_valve_motor.h vibrater_motor.c vibrater_motor.h voice.c voice.h
  group source/middleware/kernel
    ../../source/middleware/kernel/: cpu_usage.c cpu_usage.h dtimer.c dtimer.h event.c event.h msg.c msg.h stop_watch.c stop_watch.h timer.c timer.h
  group source/ui_common
    ../../source/ui_common/: screen.cpp screen.h ui_common.cpp ui_common.h ui_define.h ui_theme_define.h
  group source/ui_common/resource
    ../../source/ui_common/resource/: constant_byte_define.h font_data.c font_data.h generated_font_data.h generated_image_data.h generated_image_id.h generated_string_data.h generated_string_id.h image_data.c image_data.h string_data.c string_data.h
  group source/ui_common/resource/font
    ../../source/ui_common/resource/font/: dengxian_regular_14.c heiti_regular_60.c heiti_regular_88.c
  group source/ui_common/resource/image
    ../../source/ui_common/resource/image/: AC.c battery_AC.c battery_empty.c battery_full.c battery_no.c battery_one.c battery_three.c battery_two.c error.c exhaust.c exhaust_pause.c exhaust_run.c flush_max_dose_selected.c flush_max_dose_unselected.c history_log.c info_select.c info_unselect.c infusion_pause.c infusion_run.c infusion_stop.c left_arrow.c lock.c logo.c mode_selected.c mode_unselected.c mute.c mute_small.c new_task.c peak_set_select.c peak_set_unselect.c right_arrow.c select_1.c select_2.c selected_pointer.c set_arrow.c sound_pause.c stop_infusion.c system_setting.c time_select.c time_unselect.c unselected_pointer.c warning.c warning_common.c
  group source/ui_common/widget
    ../../source/ui_common/widget/: ui_list_pos_indicator.cpp ui_list_pos_indicator.h ui_statusbar.cpp ui_statusbar.h
  group ssz_micro_sys/bsp/simulator
    ../../lib/ssz_micro_sys/bsp/simulator/: ssz_simulator_bsp.c ssz_simulator_dev_def.h ssz_simulator_gpio_bsp.h
  group ssz_micro_sys/bsp/stm32_hal
    ../../lib/ssz_micro_sys/bsp/stm32_hal/: ssz_stm32_hal_bsp.c ssz_stm32_hal_gpio_bsp.h
  group ssz_micro_sys/include
    ../../lib/ssz_micro_sys/include/: ssz_algorithm.h ssz_block_file.h ssz_common.h ssz_def.h ssz_deque.h ssz_errorcode.h ssz_file.h ssz_gpio.h ssz_i2c.h ssz_io.h ssz_list.h ssz_locale.h ssz_map.h ssz_nvram.h ssz_precision_tick_time.h ssz_queue.h ssz_record.h ssz_safe_queue.h ssz_sim_i2c.h ssz_spi.h ssz_stack.h ssz_stop_watch.h ssz_str_utility.h ssz_tick_time.h ssz_time.h ssz_time_utility.h ssz_timer.h ssz_uart.h ssz_utility.h ssz_vector.h
  group ssz_micro_sys/source
    ../../lib/ssz_micro_sys/source/: ssz_algorithm.c ssz_block_file.c ssz_common.c ssz_deque.c ssz_file.c ssz_gpio.c ssz_i2c.c ssz_list.c ssz_locale.c ssz_map.c ssz_nvram.c ssz_precision_tick_time.c ssz_queue.c ssz_record.c ssz_safe_queue.c ssz_sim_i2c.c ssz_spi.c ssz_stack.c ssz_stop_watch.c ssz_str_utility.c ssz_tick_time.c ssz_time.c ssz_time_utility.c ssz_timer.c ssz_uart.c ssz_utility.c ssz_vector.c
  group ssz_ui/include
    ../../lib/ssz_ui/include/: ui.h ui_utility.h
  group ssz_ui/include/view
    ../../lib/ssz_ui/include/view/: ui_view.h
  group ssz_ui/include/view/widget
    ../../lib/ssz_ui/include/view/widget/: ui_draw_base.h ui_dynamic_list.h ui_edit_base.h ui_image.h ui_image_list.h ui_lable.h ui_list_base.h ui_normal_list_base.h ui_number_edit.h ui_page_control.h ui_progress_bar.h ui_text_base.h ui_text_list.h ui_window.h
  group ssz_ui/source
    ../../lib/ssz_ui/source/: ui_disp_text.c ui_draw.c ui_draw_img.c ui_internal.h ui_utility.c
  group ssz_ui/source/view
    ../../lib/ssz_ui/source/view/: ui_view.cpp
  group ssz_ui/source/view/widget
    ../../lib/ssz_ui/source/view/widget/: ui_draw_base.cpp ui_dynamic_list.cpp ui_image.cpp ui_image_list.cpp ui_lable.cpp ui_list_base.cpp ui_normal_list_base.cpp ui_number_edit.cpp ui_page_control.cpp ui_progress_bar.cpp ui_text_base.cpp ui_text_list.cpp ui_window.cpp
  group test
    ../../test/: app_sleep_suite_def.h data_suite_def.h drv_lowpower_suite_def.h drv_oled_suite_def.h drv_rtc_suite_def.h drv_sst25_flash_suite_def.h greatest.c greatest.h greatest_config.h hardware_ljl_suite_def.h record_log_suite_def.h run_all_test_suite.c run_test.c ssz_algorithm_suite_def.h ssz_str_utility_suite_def.h ssz_time_suite_def.h ssz_time_utility_suite_def.h test_app_sleep.cpp test_data.c test_drv_lowpower.cpp test_drv_oled.c test_drv_rtc.c test_drv_sst25_flash.c test_hardware_ljl.c test_record_log.c test_ssz_algorithm.c test_ssz_str_utility.c test_ssz_time.c test_ssz_time_utility.c test_ui.c test_ui_view.cpp ui_suite_def.h ui_view_suite_def.h
