<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Chemo-PumpV1_0_master.ewp</path>
  </project>
  <batchBuild/>
</workspace>


