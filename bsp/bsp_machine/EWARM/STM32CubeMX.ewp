# IAR project STM32CubeMX.ewp, settings and files
configuration STM32CubeMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162VC ST STM32L162VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L162xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32CubeMX.out
  ILINK.IlinkIcfFile: stm32l162xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l162xc.s
  group Application/User
    ./: 
    ../Src/: usart.c gpio.c spi.c stm32l1xx_it.c main.c stm32l1xx_hal_msp.c adc.c
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ./: 
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal_flash.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_adc.c stm32l1xx_hal.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c
